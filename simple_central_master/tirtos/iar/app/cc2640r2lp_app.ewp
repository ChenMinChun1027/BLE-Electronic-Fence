# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; xCC2640R2_LAUNCHXL; CC2640R2DK_5XD; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; POWER_SAVING; STACK_LIBRARY; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; DeviceFamily_CC26X0R2; Parking
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_central_cc2640r2lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  ILINK.IlinkOutputFile: simple_central_cc2640r2lp_app.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl; -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../../../../../source/ti/blestack/common/cc26xx/: board_key.c board_key.h util.c util.h
    ../../../src/app/: simple_central.c simple_central.h
  group Drivers/ECC
    ../../../../../../../../source/ti/blestack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    ../../../../../../../../source/ti/blestack/heapmgr/: heapmgr.h
    ../../../../../../../../source/ti/blestack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/blestack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/blestack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../../../../source/ti/blestack/icall/app/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/blestack/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../../../../source/ti/blestack/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/blestack/profiles/roles/: gapbondmgr.h
    ../../../../../../../../source/ti/blestack/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../../../../source/ti/blestack/profiles/roles/cc26xx/: central.c central.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    ../../../../../../../../source/ti/blestack/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_app_and_stack.icf
