# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; xCC2640R2_LAUNCHXL; CC2640R2DK_5XD; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=1; POWER_SAVING; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; $SRC_BLE$/common/cc26xx/time; ..\..\..\src/app; ..\..\..\src/app/others; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; x$SRC_BLE$/target; ../../../src/app/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $CC26XXWARE$/inc; $TI_RTOS_DRIVERS_BASE$; C:\ti\simplelink_cc2640r2_sdk_1_35_00_33\examples\rtos\CC2640R2_LAUNCHXL\blestack\CHA_Parking_Node11\src\app\boards\CC2640R2DK_5XD; C:\ti\simplelink_cc2640r2_sdk_1_35_00_33\examples\rtos\CC2640R2_LAUNCHXL\blestack\Park_node\src\app\others
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc2640r2lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  ILINK.IlinkOutputFile: simple_peripheral_cc2640r2lp_app.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: C:\ti11\simplelink_cc2640r2_sdk_1_35_00_33\source\ti\blestack\common\cc26xx\iar\cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\ble_rom_releases\cc26xx_r2\Final_Release\common_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_OAD_ImgB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: xCC2640R2_LAUNCHXL; CC2640R2DK_5XD; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; xFEATURE_OAD; IMAGE_INVALIDATE; HAL_IMAGE_B; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=1; POWER_SAVING; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\..\..\..\oad_target\tirtos\iar\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\..\..\..\oad_target\tirtos\iar\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; $SRC_BLE$/common/cc26xx/time; ..\..\..\src/app; ..\..\..\src/app/others; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/oad/cc26xx; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; x$SRC_BLE$/target; ../../../src/app/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $CC26XXWARE$/inc; $TI_RTOS_DRIVERS_BASE$; C:\ti\simplelink_cc2640r2_sdk_1_35_00_33\examples\rtos\CC2640R2_LAUNCHXL\blestack\CHA_Parking_Node11\src\app\boards\CC2640R2DK_5XD
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs  NO_ROM=1,OAD_IMG_B=1
  postbuild: "$TOOLS_BLE$\oad\oad_image_tool.exe" "FlashROM_OAD_ImgB\Exe\simple_peripheral_cc2640r2lp_app.hex" -t onchip -i app --imgVer 0 --usrId BBBB -ob "FlashROM_OAD_ImgB\Exe\simple_peripheral_cc2640r2lp_app_oad.bin" -m 0x7000 --r 0x7000
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ONLY_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\..\..\..\oad_target\tirtos\iar\config\iar_boundary.xcl
configuration FlashROM_StackLibrary (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; STACK_LIBRARY; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl; -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
configuration FlashROM_StackLibrary_RCOSC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; STACK_LIBRARY; USE_CORE_SDK; USE_ICALL; USE_RCOSC; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; $SRC_BLE$/common/cc26xx/rcosc; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: as above
  ILINK.IlinkAdditionalLibs: as above
  group Application
    ../../../src/app/others/: bsp_i2c.c bsp_i2c.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    ../../../src/app/: rtc_clock.c rtc_clock.h simple_peripheral.c simple_peripheral.h
    ../../../../../../../../source/ti/blestack/common/cc26xx/: util.c util.h
  group Drivers
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    ../../../../../../../../source/ti/blestack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../../../../../../source/ti/blestack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    ../../../../../../../../source/ti/blestack/heapmgr/: heapmgr.h
    ../../../../../../../../source/ti/blestack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/blestack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/blestack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../../../../source/ti/blestack/icall/app/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/blestack/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../../../../source/ti/blestack/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/blestack/profiles/roles/: gapbondmgr.h
    ../../../../../../../../source/ti/blestack/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../../../../source/ti/blestack/profiles/dev_info/cc26xx/: devinfoservice.c
    ../../../../../../../../source/ti/blestack/profiles/dev_info/: devinfoservice.h
    ../../../../../../../../source/ti/blestack/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../../../../source/ti/blestack/host/: gatt_uuid.c gattservapp_util.c
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: oad.c oad.h oad_reset_service.c oad_target.h oad_target_internal_flash.c
    ../../../../../../../../source/ti/blestack/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../../../../../../../source/ti/blestack/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    ../../../../../../../../source/ti/blestack/profiles/simple_profile/: simple_gatt_profile.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    ../../../src/app/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../../../../source/ti/blestack/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_and_stack.icf
